<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x667A;&#x80FD;&#x9001;&#x836F;&#x5C0F;&#x8F66;.ewp</path>
  </project>
  <batchBuild/>
</workspace>



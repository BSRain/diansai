# IAR project main.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group (top)
    ./: Black_All.h Black_Define.h Black_DELAY.c Black_DELAY.h Black_GPIO.c Black_GPIO.h Black_Init.c Black_Init.h Black_INTERRUPT.c Black_INTERRUPT.h Black_KEY.c Black_KEY.h Black_LED.c Black_LED.h Black_PWM.c Black_PWM.h Black_readme.c Black_USART.c Black_USART.h font.h main.c oled.c oled.h type.h

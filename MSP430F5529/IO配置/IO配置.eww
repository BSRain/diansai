<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IO&#x914D;&#x7F6e;.ewp</path>
  </project>
  <batchBuild/>
</workspace>



<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x6355;&#x6349;&#x4e0A;&#x5347;&#x6CBF;.ewp</path>
  </project>
  <batchBuild/>
</workspace>



<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x5e8F;&#x5217;&#x901A;&#x9053;&#x5355;&#x6B21;&#x8F6C;&#x6362;.ewp</path>
  </project>
  <batchBuild/>
</workspace>



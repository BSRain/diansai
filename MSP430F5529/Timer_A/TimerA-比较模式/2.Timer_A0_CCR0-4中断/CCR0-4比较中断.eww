<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CCR0-4&#x6BD4;&#x8F83;&#x4e2D;&#x65AD;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


